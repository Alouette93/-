# Keil uVision project f411_template.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f411_template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ..\A_CMSIS\Core;..\A_CMSIS\Other;..\A_CMSIS\StartupFile;..\B_STDPERIPH\inc;..\C_SYSTEM\delay;..\C_SYSTEM\sys;..\C_SYSTEM\usart;.\led;..\B_STDPERIPH;..\C_SYSTEM\usart2;.\key;.\exit;.\wkup;.\iptcap;.\pwm;.\timer;.\iic;..\C_SYSTEM\oled;..\C_SYSTEM\loudspeaker;..\C_SYSTEM\hc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../A_CMSIS/StartupFile/: startup_stm32f411xe.s
    ../A_CMSIS/Other/: system_stm32f4xx.c stm32f4xx.h
    ../A_CMSIS/Core/: core_cm4.h
  group STDPERIPH
    ../B_STDPERIPH/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_pwr.c
    ../B_STDPERIPH/: stm32f4xx_it.c stm32f4xx_conf.h stm32f4xx_it.h
  group SYSTEM
    ../C_SYSTEM/delay/: delay.c
    ../C_SYSTEM/sys/: sys.c
    ../C_SYSTEM/usart/: usart.c
    ../C_SYSTEM/usart2/: usart2.c
    ../C_SYSTEM/hc/: hc.c hc.h
    ../C_SYSTEM/loudspeaker/: loudspeaker.c loudspeaker.h
    ../C_SYSTEM/oled/: oled.c oled.h
  group USER
    ./: main.c
    ./led/: led.c
    ./key/: key.c
    ./exit/: exit.c
    ./iptcap/: iptcap.c
    ./pwm/: pwm.c
    ./timer/: timer.c
    ./iic/: iic.c
